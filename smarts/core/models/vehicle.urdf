Commit message: Update parameters for BMs

File: smarts/core/models/vehicle.urdf (robot description, URDF)
Before this commit: robot vehicle, 8 links, 7 joints
Links:
- link chassis: mass 2356.0 -> 1356.0
